# Keil uVision project HW_LiteOS_demo.uvprojx, settings and files
target HW_LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HW_LiteOS_demo +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\inc;..\USER;..\HardWare\SYSTEM;..\LiteOS_Kernel-master\kernel\base\include;..\LiteOS_Kernel-master\kernel\config;..\LiteOS_Kernel-master\kernel\include;..\LiteOS_Kernel-master\kernel\link\keil;..\LiteOS_Kernel-master\platform\LOS_EXPAND_XXX;..\LiteOS_Kernel-master\kernel\cpu\arm\cortex-m3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\USER\HW_LiteOS_CortexM.sct
  group STARTUP
    ../Libraries/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/src/: misc.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HW_LiteOS_Kernel
    ../LiteOS_Kernel-master/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS_Kernel-master/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS_Kernel-master/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../LiteOS_Kernel-master/kernel/base/misc/: los_misc.c
  group HW_LiteOS_Platform
    ../LiteOS_Kernel-master/kernel/config/: los_config.c
    ../LiteOS_Kernel-master/kernel/cpu/arm/cortex-m3/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
    ../LiteOS_Kernel-master/platform/LOS_EXPAND_XXX/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group USER
    ../USER/: main.c stm32f10x_conf.h ARC_SysTick.c ARC_SysTick.h
